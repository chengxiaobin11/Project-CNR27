# Keil uVision project STD_FW_1P.uvproj, settings and files
target RL6369_Project (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: RL6369_Project +hex (library)
  BeforeMake: .\Tool\precompile\pch_support.bat @L !P "" "$K"
  AfterMake: ".\Tool\build\link.bat" "$K" !P @L
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RL6369_PROJECT, _SCALER_TYPE = _RL6369_SERIES
  c include: .\Output\RL6369;.\Project\Header;.\Pcb;.\Panel;.\Kernel\Device\Header;.\Kernel\Common;.\Kernel\System\Header;.\Kernel\Scaler\ScalerCommonFunction\Header;.\Kernel\Scaler\ScalerCommonFunction\Lib\Header;.\Kernel\Scaler\ScalerFunction\Header;.\Kernel\Scaler\ScalerFunction\Lib\Header;.\Kernel\Scaler\RL6369_Series_Scaler\Header;.\Kernel\Scaler\RL6369_Series_Scaler\Lib\Header;.\Kernel\User Common Function\Header;.\User\RTD Series\RTD2014Function\Header;.\User\RTD Series\RTD2014Osd\Header;.\User\RTD Factory\Header;.\User\None Series\NoneFunction\Header;.\User\None Series\NoneOsd\Header;.\User\None Factory\Header
  asm misc: DEFINE(_PROJECT=_RL6369_PROJECT,_SCALER_TYPE=_RL6369_SERIES)
  asm include: .\Project\Header;.\Kernel\Common
  group Project
    ./Project/Header/: User_Project_List.h User_Project_Include.h User_Project_Option.h User_Scaler_Option.h RL6369_Project.h RL6432_Project.h RL6410_Project.h RL6449_Project.h RL6463_Project.h RL6492_Project.h RL6851_Project.h
  group Pcb
    ./Pcb/: User_Pcb_List.h User_Pcb_Include.h User_Pcb_Option.h
    ./Pcb/RL6369/LQFP_128/: RL6369_PCB_EXAMPLE_128_PIN.h RL6369_DEMO_128PIN_1A2MHL1DP.h RL6369_QA_128PIN_1A2MHL1DP.h
    ./Pcb/RL6369/QFN_76/: RL6369_PCB_EXAMPLE_76_PIN.h RL6369_DEMO_76PIN_1A1DP.h RL6369_DEMO_76PIN_1A1DVI.h RL6369_DEMO_76PIN_1A1H.h
    ./Pcb/RL6410/BGA_1024/: RL6410_PCB_EXAMPLE.h RL6410_DEMO_5K3K_2H2DP_LVDS_eDP.h RL6410_DEMO_A_1A4MHL2DP_DPTX_LVDS_eDP.h RL6410_DEMO_B_1A4MHL1DP1mDP_DPTX_LVDS_eDP.h RL6410_DEMO_C_1A2MHL1DP1mDP1DUALDVI_DPTX_LVDS_eDP.h RL6410_DEMO_D_1A4MHL1DP1mDP_DPTX_LVDS_VB1.h RL6410_DEMO_E_1A4MHL2DP_DPTX_LVDS_VB1.h RL6410_DEMO_LOCAL_DIMMING_2MHL1DP1mDP.h RL6410_DEMO_TC_3MHL1TC1DP_DPTX_LVDS_eDP.h RL6410_QA_A_1A4MHL1DP1mDP_DPTX_LVDS_eDP.h RL6410_QA_B_1A6mDP_DPTX_LVDS_eDP.h RL6410_DEMO_B_FS2_DIMMING_1A4MHL1DP1mDP_DPTX_LVDS_eDP.h RL6410_QA_A_MOTION_BLUR_REDUCTION.h
    ./Pcb/RL6432/LQFP_156_MST/: RL6432_PCB_EXAMPLE_156_PIN_MST.h RL6432_QA_C_156PIN_1MHL2DP_DPTX_LVDS_eDP.h
    ./Pcb/RL6432/LQFP_156_VGA/: RL6432_PCB_EXAMPLE_156_PIN_VGA.h RL6432_QA_B_156PIN_1A1MHL2DP_LVDS_eDP.h
    ./Pcb/RL6432/LQFP_216/: RL6432_PCB_EXAMPLE_216_PIN.h RL6432_DEMO_A_216PIN_1A2MHL1DP1mDP_DPTX_LVDS_eDP.h RL6432_DEMO_B_216PIN_1A1MHL1DP1DUALDVI_DPTX_LVDS_eDP.h RL6432_DEMO_C_D_216PIN_1A2MHL1DP1mDP_DPTX_LVDS_eDP.h RL6432_DEMO_E_216PIN_2MHL1TC1DP_DPTX_LVDS_eDP.h RL6432_QA_A_216PIN_1A2MHL1DP1mDP_DPTX_LVDS_eDP.h RL6432_QA_B_216PIN_1A2MHL2DP_DPTX_LVDS_eDP.h RL6432_QA_A_MOTION_BLUR_REDUCTION.h
    ./Pcb/RL6432/QFN_76/: RL6432_PCB_EXAMPLE_76_PIN.h RL6432_QA_B_76PIN_1A1DP_eDP.h
    ./Pcb/RL6449/LQFP_156/: RL6449_PCB_EXAMPLE_156_PIN.h
    ./Pcb/RL6449/LQFP_216/: RL6449_PCB_EXAMPLE_216_PIN.h RL6449_DEMO_A_1A2MHL1DP1mDP_DPTX_eDP.h RL6449_DEMO_B_1A2MHL1DP1mDP_DPTX_eDP.h RL6449_DEMO_C_1A2MHL1DP1mDP_DPTX_eDP.h RL6449_DEMO_D_1A2MHL1DP1mDP_DPTX_eDP.h RL6449_DEMO_E_1A1H1DP_DPTX_eDP.h RL6449_DEMO_F_1A2MHL1DP1mDP_DPTX_VB1.h RL6449_DEMO_LOCAL_DIMMING_1DP1mDP1H.h RL6449_DEMO_LOCAL_DIMMING_1USB1H1TC.h RL6449_QA_A_1A2MHL1DP1mDP_DPTX_eDP.h RL6449_QA_A_MOTION_BLUR_REDUCTION_1A2MHL1DP1mDP_DPTX_eDP.h RL6449_QA_B_1A2MHL1DP1mDP_DPTX_eDP.h
    ./Pcb/RL6463/LQFP_128/: RL6463_PCB_EXAMPLE_128_PIN.h RL6463_DEMO_128PIN_1A1H1DP_PC99.h RL6463_QA_128PIN_1A1H1DP.h
    ./Pcb/RL6463/QFN_76/: RL6463_PCB_EXAMPLE_76_PIN.h RL6463_DEMO_76PIN_1A1DP_PC99.h RL6463_DEMO_B_76PIN_1A1H.h RL6463_QA_76PIN_1A1DP.h
    ./Pcb/RL6492/LQFP_156/: RL6492_PCB_EXAMPLE_156_PIN.h RL6492_DEMO_A_156PIN_1A2H1DP_LVDS_eDP.h RL6492_DEMO_B_156PIN_1A1H1TC1DP_LVDS_eDP.h RL6492_DEMO_B_156PIN_1A1H1TC1DP_LVDS_eDP_PN_SWAP.h RL6492_DEMO_D_156PIN_1A1H1TC1DP_LVDS_eDP.h RL6492_QA_156PIN_1A1H1TC1DP_LVDS_eDP.h RL6492_DEMO_E_156PIN_1A1H1TC1DP_LVDS_eDP.h
    ./Pcb/RL6851/LQFP_128/: RL6851_DEMO_A_128PIN_1A1H1DP_LVDS.h RL6851_DEMO_A_128PIN_1A1H1DP_LVDS_PINSHARE.h RL6851_PCB_EXAMPLE_128_PIN.h RL6851_PCB_EXAMPLE_128_PIN_PINSHARE.h RL6851_QA_A_128PIN_1A1H1DP_LVDS.h RL6851_QA_A_128PIN_1A1H1DP_LVDS_PINSHARE.h
    ./Pcb/RL6851/QFN_76/: RL6851_DEMO_A_76PIN_1A1DP_LVDS.h RL6851_DEMO_A_76PIN_1A1DP_LVDS_PINSHARE.h RL6851_PCB_EXAMPLE_76_PIN.h RL6851_PCB_EXAMPLE_76_PIN_PINSHARE.h RL6851_QA_A_76PIN_1A1DP_LVDS.h RL6851_QA_A_76PIN_1A1DP_LVDS_PINSHARE.h
  group Common
    ./Kernel/Common/: reg52_RTD.h L51_bank.a51 STARTUP.a51 C_STARTUP.a51 Debug.h Global.h Project.h Scaler_Test_Function.h RL6369_Gen_Option.h RL6369_Project_Default.h RL6369_Pcb_Default.h RL6410_Gen_Option.h RL6410_Project_Default.h RL6410_Pcb_Default.h RL6432_Gen_Option.h RL6432_Project_Default.h RL6432_Pcb_Default.h RL6463_Gen_Option.h RL6463_Project_Default.h RL6463_Pcb_Default.h RL6851_Gen_Option.h RL6851_OSD_Gen_Option.h RL6851_Pcb_Default.h RL6851_Project_Default.h
  group Panel
    ./Panel/: User_Panel_List.h User_Panel_Include.h User_Panel_Option.h 00_CMO_LVDS_17.h 01_CMO_LVDS_19_WXGA.h 02_AU_LVDS_21_5_WUXGA.h 03_AU_LVDS_27_WUXGA_FREESYNC.h 04_MULTIPANEL_LVDS_21_5_WUXGA.h 05_AU_LVDS_22_WSXGA.h 06_AU_LVDS_22_WSXGA_QC.h 07_AU_LVDS_23_WUXGA.h 08_AU_LVDS_24_WUXGA.h 09_AU_DP_21_5_WUXGA.h 10_LG_LED_DP_27_UHD.h 14_LG_LED_LVDS_27_WUXGA.h 15_SAMSUNG_LED_DP_15_6_UHD.h 16_AUO_LED_DP_32_UHD.h 17_SAMSUNG_LED_DP_23_6_UHD.h 18_INNOLUX_LED_VBO_28_UHD.h 19_LG_LED_LVDS_23_UHD.h 20_INNOLUX_LED_VBO_40_UHD.h 21_AU_LVDS_21_5_WUXGA_FREESYNC.h 23_LG_LED_DP_27_QHD.h 24_LG_LED_DP_27_QHD_QC.h 25_AU_DP_21_5_WUXGA_FREESYNC.h 26_INNOLUX_TTL_7.h 27_MULTIPANEL_DP_21_5_WUXGA.h 22_LG_LED_DP_27_QQHD.h 28_LG_LED_DP_17_QHD.h 29_LG_LED_DP_34_WFHD.h 30_AUO_eDP_27_UHD.h 31_AUO_VBO_27_WUXGA_FREESYNC.h
    ./Panel/EXAMPLE/: PANEL_LVDS_EXAMPLE.h PANEL_DPTX_EXAMPLE.h PANEL_VBO_EXAMPLE.h
  group System
    ./Kernel/System/Header/: SysInterface.h SysInclude.h
    ./Kernel/System/Code/: SysAudio.c SysDP.c SysInt.c SysJudge.c SysMain.c SysMHL.c SysMode.c SysPower.c SysSource.c SysTimer.c SysTMDS.c SysVGA.c SysColor.c SysTypeC.c SysAutotest.c SysCec.c
  group ScalerFunction
    ./Kernel/Scaler/ScalerFunction/Header/: ScalerFunctionCommonInclude.h ScalerFunctionInclude.h ScalerFunctionInterface.h
    ./Kernel/Scaler/ScalerFunction/Code/: ScalerADC.c ScalerAudio.c ScalerAutoFunc.c ScalerColor.c ScalerDDomain.c ScalerDDR1.c ScalerDDR3.c ScalerDisplay.c ScalerDisplayDPTx.c ScalerDPRxMST.c ScalerDPRx0.c ScalerDPRx0HDCP2.c ScalerDPRx1HDCP2.c ScalerDPTx.c ScalerDPTxHDCP2.c ScalerDualLinkDVI.c ScalerFormatConversion.c ScalerFRC.c ScalerGDIPhyTx.c ScalerGlobal.c ScalerIDomain.c ScalerIR.c ScalerLCTank.c ScalerMbr.c ScalerMcu.c ScalerMDomain.c ScalerMeasure.c ScalerMemory.c ScalerOD.c ScalerOsd.c ScalerPinshare.c ScalerPLL.c ScalerPower.c ScalerRotation.c ScalerReg.c ScalerSDRAM.c ScalerSync.c ScalerSyncProc.c ScalerTimerFunction.c ScalerVGATop.c ScalerVGIP.c ScalerCec.c
  group ScalerFunction_ComboPhy
    ./Kernel/Scaler/ScalerFunction/Code/: ScalerAudio_ComboPhy.c ScalerDP_ComboPhy.c ScalerDPRx0_ComboPhy.c ScalerDPRx0_INT_ComboPhy.c ScalerTMDS_ComboPhy.c
  group ScalerFunction_SeptPhy
    ./Kernel/Scaler/ScalerFunction/Code/: ScalerAudio_SeptPhy.c ScalerDP_SeptPhy.c ScalerDPRx0_INT_SeptPhy.c ScalerDPRx0_SeptPhy.c ScalerDPRx1_INT_SeptPhy.c ScalerDPRx1_SeptPhy.c ScalerDPRx1HDCP2_SeptPhy.c ScalerDPRxMST_SeptPhy.c ScalerMHL3Rx2_SeptPhy.c ScalerMHL3Rx3_SeptPhy.c ScalerMHLRx2_SeptPhy.c ScalerMHLRx3_SeptPhy.c ScalerMHLRx4_SeptPhy.c ScalerMHLRx5_SeptPhy.c ScalerTMDSRx1_SeptPhy.c ScalerTMDSRx1HDCP2_SeptPhy.c ScalerTMDSRx2_SeptPhy.c ScalerTMDSRx2HDCP2_SeptPhy.c ScalerTMDSRx3_SeptPhy.c ScalerTMDSRx3HDCP2_SeptPhy.c ScalerTMDSRx4_SeptPhy.c ScalerTMDSRx4HDCP2_SeptPhy.c ScalerTMDSRx5_SeptPhy.c ScalerTMDSRx5HDCP2_SeptPhy.c
  group ScalerCommonFunction
    ./Kernel/Scaler/ScalerCommonFunction/Header/: ScalerCommonFunctionCommonInclude.h ScalerCommonFunctionInclude.h ScalerCommonFunctionInterface.h
    ./Kernel/Scaler/ScalerCommonFunction/Code/: ScalerCommonColor.c ScalerCommonDebug.c ScalerCommonDPRx0.c ScalerCommonDPRx0HDCP2.c ScalerCommonDPRx1.c ScalerCommonDPRx1HDCP2.c ScalerCommonDPRxMST.c ScalerCommonDPTx.c ScalerCommonDPTxAux.c ScalerCommonDPTxHDCP2.c ScalerCommonDPTxMST.c ScalerCommonFreeSync.c ScalerCommonHDCP2.c ScalerCommonIOSC.c ScalerCommonMcu.c ScalerCommonMeasure.c ScalerCommonNVRam.c ScalerCommonPLL.c ScalerCommonPower.c ScalerCommonReg.c ScalerCommonSpi.c ScalerCommonSync.c ScalerCommonTimerFunction.c ScalerCommonTMDS.c ScalerCommonTypeC.c ScalerCommonTypeCPmic.c ScalerCommonTypeCPower.c ScalerCommonTypeCRx0Cc.c ScalerCommonTypeCRx0Pd.c ScalerCommonUSB3Retimer.c ScalerCommonFwInfo.c ScalerCommonDpAdaptiveSync.c ScalerCommonFwCheck.c ScalerCommonFwUpdate.c ScalerCommonFwUpdateBackground.c ScalerCommonFwUpdateForeground.c
  group RL6369_Series_Scaler
    ./Kernel/Scaler/RL6369_Series_Scaler/Lib/Output/: RL6369_FunctionLib.LIB
    ./Kernel/Scaler/RL6369_Series_Scaler/Header/: RL6369_Series_FunctionCommonInclude.h RL6369_Series_FunctionInclude.h RL6369_Series_FunctionInterface.h
    ./Kernel/Scaler/RL6369_Series_Scaler/Code/: RL6369_Series_ADC.c RL6369_Series_Audio.c RL6369_Series_Color.c RL6369_Series_DDomain.c RL6369_Series_DDR1.c RL6369_Series_Display.c RL6369_Series_DP.c RL6369_Series_DP_INT.c RL6369_Series_DPRx0.c RL6369_Series_DPRx0_INT.c RL6369_Series_FRC.c RL6369_Series_GDIPhy.c RL6369_Series_Global.c RL6369_Series_HDCP2.c RL6369_Series_IDomain.c RL6369_Series_LDO.c RL6369_Series_Mcu.c RL6369_Series_MDomain.c RL6369_Series_Measure.c RL6369_Series_Memory.c RL6369_Series_MHL.c RL6369_Series_OD.c RL6369_Series_Osd.c RL6369_Series_Pinshare.c RL6369_Series_PLL.c RL6369_Series_Power.c RL6369_Series_QC_BIST.c RL6369_Series_QC_Color.c RL6369_Series_QC_Common.c RL6369_Series_QC_DSPC.c RL6369_Series_QC_Main.c RL6369_Series_QC_OD_FRC.c RL6369_Series_QC_OSD.c RL6369_Series_Reg.c RL6369_Series_Scaling.c RL6369_Series_SDRAM.c RL6369_Series_Sync.c RL6369_Series_SyncProc.c RL6369_Series_TCON.c RL6369_Series_TimerFunction.c RL6369_Series_TMDS.c RL6369_Series_VGATop.c RL6369_Series_VGIP.c RL6369_Series_Efuse.c
  group RL6410_Series_Scaler
    ./Kernel/Scaler/RL6410_Series_Scaler/Lib/Output/: RL6410_FunctionLib.LIB
    ./Kernel/Scaler/RL6410_Series_Scaler/Header/: RL6410_Series_FunctionCommonInclude.h RL6410_Series_FunctionInclude.h RL6410_Series_FunctionInterface.h
    ./Kernel/Scaler/RL6410_Series_Scaler/Code/: RL6410_Series_ADC.c RL6410_Series_Audio.c RL6410_Series_Color.c RL6410_Series_DDomain.c RL6410_Series_DDR3.c RL6410_Series_Display.c RL6410_Series_DisplayDPTx.c RL6410_Series_DP.c RL6410_Series_DP_INT.c RL6410_Series_DPRx0.c RL6410_Series_DPRx0_INT.c RL6410_Series_DPRx1.c RL6410_Series_DPRx1_INT.c RL6410_Series_DPRxMST.c RL6410_Series_DPTx.c RL6410_Series_DPTxMST.c RL6410_Series_DualLinkDVI.c RL6410_Series_FormatConversion.c RL6410_Series_FRC.c RL6410_Series_GDIPhy.c RL6410_Series_Global.c RL6410_Series_IDomain.c RL6410_Series_LDO.c RL6410_Series_Mcu.c RL6410_Series_MDomain.c RL6410_Series_Measure.c RL6410_Series_Memory.c RL6410_Series_MHL.c RL6410_Series_MHLRx2.c RL6410_Series_MHLRx3.c RL6410_Series_MHLRx4.c RL6410_Series_MHLRx5.c RL6410_Series_OD.c RL6410_Series_Osd.c RL6410_Series_Pinshare.c RL6410_Series_PLL.c RL6410_Series_Power.c RL6410_Series_QC_BIST.c RL6410_Series_QC_Color_DDomain.c RL6410_Series_QC_Color_DDomain_II.c RL6410_Series_QC_Color_DDomain_III.c RL6410_Series_QC_Color_DDomain_IV.c RL6410_Series_QC_Color_DDomain_V.c RL6410_Series_QC_Color_DDomain_VI.c RL6410_Series_QC_Color_IMDomain.c RL6410_Series_QC_Common.c RL6410_Series_QC_DSPC.c RL6410_Series_QC_Main.c RL6410_Series_QC_OD_FRC.c RL6410_Series_QC_OSD.c RL6410_Series_Rotation.c RL6410_Series_Scaling.c RL6410_Series_Sync.c RL6410_Series_SyncProc.c RL6410_Series_TCON.c RL6410_Series_TimerFunction.c RL6410_Series_TMDS.c RL6410_Series_TMDSRx2.c RL6410_Series_TMDSRx3.c RL6410_Series_TMDSRx4.c RL6410_Series_TMDSRx5.c RL6410_Series_VGATop.c RL6410_Series_VGIP.c
  group RL6410_Series_Common
    ./Kernel/Scaler/RL6410_Series_Common/Header/: RL6410_Series_Common_FunctionCommonInclude.h RL6410_Series_Common_FunctionInclude.h RL6410_Series_Common_FunctionInterface.h
    ./Kernel/Scaler/RL6410_Series_Common/Code/: RL6410_Series_Common_Reg.c
  group RL6432_Series_Scaler
    ./Kernel/Scaler/RL6432_Series_Scaler/Lib/Output/: RL6432_FunctionLib.LIB
    ./Kernel/Scaler/RL6432_Series_Scaler/Header/: RL6432_Series_FunctionCommonInclude.h RL6432_Series_FunctionInclude.h RL6432_Series_FunctionInterface.h
    ./Kernel/Scaler/RL6432_Series_Scaler/Code/: RL6432_Series_ADC.c RL6432_Series_Audio.c RL6432_Series_Color.c RL6432_Series_DDomain.c RL6432_Series_DDR1.c RL6432_Series_Display.c RL6432_Series_DisplayDPTx.c RL6432_Series_DP.c RL6432_Series_DP_INT.c RL6432_Series_DPRx0.c RL6432_Series_DPRx0_INT.c RL6432_Series_DPRx1.c RL6432_Series_DPRx1_INT.c RL6432_Series_DPRxMST.c RL6432_Series_DPTx.c RL6432_Series_DPTxMST.c RL6432_Series_DualLinkDVI.c RL6432_Series_FormatConversion.c RL6432_Series_FRC.c RL6432_Series_GDIPhy.c RL6432_Series_Global.c RL6432_Series_IDomain.c RL6432_Series_LDO.c RL6432_Series_Mcu.c RL6432_Series_MDomain.c RL6432_Series_Measure.c RL6432_Series_Memory.c RL6432_Series_MHL.c RL6432_Series_MHLRx1.c RL6432_Series_MHLRx2.c RL6432_Series_MHLRx3.c RL6432_Series_OD.c RL6432_Series_Osd.c RL6432_Series_Pinshare.c RL6432_Series_PLL.c RL6432_Series_Power.c RL6432_Series_QC_BIST.c RL6432_Series_QC_Color_DDomain.c RL6432_Series_QC_Color_DDomain_II.c RL6432_Series_QC_Color_DDomain_III.c RL6432_Series_QC_Color_IMDomain.c RL6432_Series_QC_DSPC.c RL6432_Series_QC_Main.c RL6432_Series_QC_OD_FRC.c RL6432_Series_QC_OSD.c RL6432_Series_Rotation.c RL6432_Series_Scaling.c RL6432_Series_SDRAM.c RL6432_Series_Sync.c RL6432_Series_SyncProc.c RL6432_Series_TCON.c RL6432_Series_TimerFunction.c RL6432_Series_TMDS.c RL6432_Series_TMDSRx1.c RL6432_Series_TMDSRx2.c RL6432_Series_TMDSRx3.c RL6432_Series_VGATop.c RL6432_Series_VGIP.c RL6432_Series_Efuse.c
  group RL6432_Series_Common
    ./Kernel/Scaler/RL6432_Series_Common/Header/: RL6432_Series_Common_FunctionCommonInclude.h RL6432_Series_Common_FunctionInclude.h RL6432_Series_Common_FunctionInterface.h
    ./Kernel/Scaler/RL6432_Series_Common/Code/: RL6432_Series_Common_Reg.c
  group RL6449_Series_Scaler
    ./Kernel/Scaler/RL6449_Series_Scaler/Lib/Output/: RL6449_FunctionLib.LIB
    ./Kernel/Scaler/RL6449_Series_Scaler/Header/: RL6449_Series_FunctionCommonInclude.h RL6449_Series_FunctionInclude.h RL6449_Series_FunctionInterface.h
    ./Kernel/Scaler/RL6449_Series_Scaler/Code/: RL6449_Series_ADC.c RL6449_Series_Audio.c RL6449_Series_Color.c RL6449_Series_DDomain.c RL6449_Series_DDR2.c RL6449_Series_Display.c RL6449_Series_DisplayDPTx.c RL6449_Series_DP.c RL6449_Series_DP_INT.c RL6449_Series_DPRx0.c RL6449_Series_DPRx0_INT.c RL6449_Series_DPRx1.c RL6449_Series_DPRx1_INT.c RL6449_Series_DPRxMST.c RL6449_Series_DPTx.c RL6449_Series_DPTxMST.c RL6449_Series_FormatConversion.c RL6449_Series_FRC.c RL6449_Series_GDIPhy.c RL6449_Series_Global.c RL6449_Series_IDomain.c RL6449_Series_LDO.c RL6449_Series_Mcu.c RL6449_Series_MDomain.c RL6449_Series_Measure.c RL6449_Series_Memory.c RL6449_Series_MHL.c RL6449_Series_MHLRx2.c RL6449_Series_MHLRx3.c RL6449_Series_OD.c RL6449_Series_Osd.c RL6449_Series_Pinshare.c RL6449_Series_PLL.c RL6449_Series_Power.c RL6449_Series_QC_BIST.c RL6449_Series_QC_Color_DDomain.c RL6449_Series_QC_Color_DDomain_II.c RL6449_Series_QC_Color_DDomain_III.c RL6449_Series_QC_Color_DDomain_IV.c RL6449_Series_QC_Color_DDomain_V.c RL6449_Series_QC_Color_IMDomain.c RL6449_Series_QC_Common.c RL6449_Series_QC_DSPC.c RL6449_Series_QC_Main.c RL6449_Series_QC_OD_FRC.c RL6449_Series_QC_OSD.c RL6449_Series_Rotation.c RL6449_Series_Scaling.c RL6449_Series_Sync.c RL6449_Series_SyncProc.c RL6449_Series_TCON.c RL6449_Series_TimerFunction.c RL6449_Series_TMDS.c RL6449_Series_TMDSRx2.c RL6449_Series_TMDSRx3.c RL6449_Series_VGATop.c RL6449_Series_VGIP.c
  group RL6449_Series_Common
    ./Kernel/Scaler/RL6449_Series_Common/Header/: RL6449_Series_Common_FunctionCommonInclude.h RL6449_Series_Common_FunctionInterface.h RL6449_Series_Common_FunctionInclude.h
    ./Kernel/Scaler/RL6449_Series_Common/Code/: RL6449_Series_Common_Reg.c
  group RL6463_Series_Scaler
    ./Kernel/Scaler/RL6463_Series_Scaler/Lib/Output/: RL6463_FunctionLib.LIB
    ./Kernel/Scaler/RL6463_Series_Scaler/Header/: RL6463_Series_FunctionCommonInclude.h RL6463_Series_FunctionInclude.h RL6463_Series_FunctionInterface.h
    ./Kernel/Scaler/RL6463_Series_Scaler/Code/: RL6463_Series_ADC.c RL6463_Series_Audio.c RL6463_Series_Color.c RL6463_Series_DDomain.c RL6463_Series_Display.c RL6463_Series_DP.c RL6463_Series_DP_INT.c RL6463_Series_DPRx0.c RL6463_Series_DPRx0_INT.c RL6463_Series_Efuse.c RL6463_Series_FRC.c RL6463_Series_GDIPhy.c RL6463_Series_Global.c RL6463_Series_IDomain.c RL6463_Series_LDO.c RL6463_Series_Mcu.c RL6463_Series_MDomain.c RL6463_Series_Measure.c RL6463_Series_Memory.c RL6463_Series_OD.c RL6463_Series_Osd.c RL6463_Series_PC99EDID.c RL6463_Series_Pinshare.c RL6463_Series_PLL.c RL6463_Series_Power.c RL6463_Series_Reg.c RL6463_Series_Scaling.c RL6463_Series_SDRAM.c RL6463_Series_Sync.c RL6463_Series_SyncProc.c RL6463_Series_TCON.c RL6463_Series_TimerFunction.c RL6463_Series_TMDS.c RL6463_Series_VGATop.c RL6463_Series_VGIP.c
  group RL6492_Series_Common
    ./Kernel/Scaler/RL6492_Series_Common/Header/: RL6492_Series_Common_FunctionCommonInclude.h RL6492_Series_Common_FunctionInclude.h RL6492_Series_Common_FunctionInterface.h
    ./Kernel/Scaler/RL6492_Series_Common/Code/: RL6492_Series_Common_Reg.c
  group RL6492_Series_Scaler
    ./Kernel/Scaler/RL6492_Series_Scaler/Lib/Output/: RL6492_FunctionLib.LIB
    ./Kernel/Scaler/RL6492_Series_Scaler/Header/: RL6492_Series_FunctionCommonInclude.h RL6492_Series_FunctionInclude.h RL6492_Series_FunctionInterface.h
    ./Kernel/Scaler/RL6492_Series_Scaler/Code/: RL6492_Series_ADC.c RL6492_Series_Audio.c RL6492_Series_BillBoard.c RL6492_Series_Color.c RL6492_Series_DDomain.c RL6492_Series_DDR1.c RL6492_Series_Display.c RL6492_Series_DisplayDPTx.c RL6492_Series_DP.c RL6492_Series_DP_INT.c RL6492_Series_DPRx0.c RL6492_Series_DPRx0_INT.c RL6492_Series_DPRx1.c RL6492_Series_DPRx1_INT.c RL6492_Series_DPRx1HDCP2.c RL6492_Series_DualLinkDVI.c RL6492_Series_Efuse.c RL6492_Series_FlashMode.c RL6492_Series_FormatConversion.c RL6492_Series_FRC.c RL6492_Series_GDIPhy.c RL6492_Series_Global.c RL6492_Series_IDomain.c RL6492_Series_LDO.c RL6492_Series_Mcu.c RL6492_Series_MDomain.c RL6492_Series_Measure.c RL6492_Series_Memory.c RL6492_Series_MHL.c RL6492_Series_MHLRx1.c RL6492_Series_MHLRx2.c RL6492_Series_OD.c RL6492_Series_Osd.c RL6492_Series_Pinshare.c RL6492_Series_PLL.c RL6492_Series_Power.c RL6492_Series_QC_BIST.c RL6492_Series_QC_Color.c RL6492_Series_QC_Color_IMDomain.c RL6492_Series_QC_Common.c RL6492_Series_QC_DSPC.c RL6492_Series_QC_Gamma.c RL6492_Series_QC_IO_Toggle.c RL6492_Series_QC_Main.c RL6492_Series_QC_OD_FRC.c RL6492_Series_QC_OSD.c RL6492_Series_Rotation.c RL6492_Series_Scaling.c RL6492_Series_SDRAM.c RL6492_Series_Sync.c RL6492_Series_SyncProc.c RL6492_Series_TCON.c RL6492_Series_TimerFunction.c RL6492_Series_TMDS.c RL6492_Series_TMDSRx1HDCP2.c RL6492_Series_TMDSRx2HDCP2.c RL6492_Series_VGATop.c RL6492_Series_VGIP.c
  group RL6851_Series_Scaler
    ./Kernel/Scaler_Group2/RL6851_Series_Scaler/Lib/Output/: RL6851_FunctionLib.LIB
    ./Kernel/Scaler_Group2/RL6851_Series_Scaler/Code/: RL6851_Series_ADC.c RL6851_Series_Audio.c RL6851_Series_Color.c RL6851_Series_DDomain.c RL6851_Series_Display.c RL6851_Series_DP.c RL6851_Series_DP_INT.c RL6851_Series_DPRx0.c RL6851_Series_DPRx0_INT.c RL6851_Series_Efuse.c RL6851_Series_FRC.c RL6851_Series_GDIPhy.c RL6851_Series_Global.c RL6851_Series_IDomain.c RL6851_Series_LDO.c RL6851_Series_Mcu.c RL6851_Series_MDomain.c RL6851_Series_Measure.c RL6851_Series_Memory.c RL6851_Series_OD.c RL6851_Series_Osd.c RL6851_Series_Pinshare.c RL6851_Series_PLL.c RL6851_Series_Power.c RL6851_Series_Reg.c RL6851_Series_ScalerADC.c RL6851_Series_ScalerAudio.c RL6851_Series_ScalerAudio_ComboPhy.c RL6851_Series_ScalerAutoFunc.c RL6851_Series_ScalerColor.c RL6851_Series_ScalerCommonColor.c RL6851_Series_ScalerCommonDebug.c RL6851_Series_ScalerCommonDPRx0.c RL6851_Series_ScalerCommonDPTx.c RL6851_Series_ScalerCommonDPTxAux.c RL6851_Series_ScalerCommonFreeSync.c RL6851_Series_ScalerCommonFwInfo.c RL6851_Series_ScalerCommonHDCP2.c RL6851_Series_ScalerCommonIOSC.c RL6851_Series_ScalerCommonMcu.c RL6851_Series_ScalerCommonMeasure.c RL6851_Series_ScalerCommonNVRam.c RL6851_Series_ScalerCommonPLL.c RL6851_Series_ScalerCommonPower.c RL6851_Series_ScalerCommonReg.c RL6851_Series_ScalerCommonSpi.c RL6851_Series_ScalerCommonSync.c RL6851_Series_ScalerCommonTimerFunction.c RL6851_Series_ScalerCommonTMDS.c RL6851_Series_ScalerDDomain.c RL6851_Series_ScalerDisplay.c RL6851_Series_ScalerDisplayDPTx.c RL6851_Series_ScalerDP_ComboPhy.c RL6851_Series_ScalerDPRx0.c RL6851_Series_ScalerDPRx0_ComboPhy.c RL6851_Series_ScalerDPRx0_INT_ComboPhy.c RL6851_Series_ScalerDPRx0HDCP2.c RL6851_Series_ScalerDPRx1HDCP2.c RL6851_Series_ScalerDPTx.c RL6851_Series_ScalerDPTxHDCP2.c RL6851_Series_ScalerFormatConversion.c RL6851_Series_ScalerFRC.c RL6851_Series_ScalerGDIPhyTx.c RL6851_Series_ScalerGlobal.c RL6851_Series_ScalerIDomain.c RL6851_Series_ScalerMcu.c RL6851_Series_ScalerMDomain.c RL6851_Series_ScalerMeasure.c RL6851_Series_ScalerMemory.c RL6851_Series_ScalerOD.c RL6851_Series_ScalerOsd.c RL6851_Series_ScalerPinshare.c RL6851_Series_ScalerPLL.c RL6851_Series_ScalerPower.c RL6851_Series_ScalerReg.c RL6851_Series_ScalerSDRAM.c RL6851_Series_ScalerSync.c RL6851_Series_ScalerSyncProc.c RL6851_Series_ScalerTimerFunction.c RL6851_Series_ScalerTMDS_ComboPhy.c RL6851_Series_ScalerVGATop.c RL6851_Series_ScalerVGIP.c RL6851_Series_Scaling.c RL6851_Series_SDRAM.c RL6851_Series_Sync.c RL6851_Series_SyncProc.c RL6851_Series_TCON.c RL6851_Series_TimerFunction.c RL6851_Series_TMDS.c RL6851_Series_VGATop.c RL6851_Series_VGIP.c RL6851_Series_ScalerCommonDpAdaptiveSync.c RL6851_Series_ScalerImgCmp.c RL6851_Series_ScalerCommonFwCheck.c RL6851_Series_DisplayDPTx.c RL6851_Series_OTP.c RL6851_Series_ThermalSensor.c RL6851_Series_ScalerCommonFwUpdate.c RL6851_Series_ScalerCommonFwUpdateBackground.c RL6851_Series_ScalerCommonFwUpdateForeground.c RL6851_Series_ScalerMbr.c RL6851_Series_ScalerCommonTypeC.c RL6851_Series_ScalerDrr.c
  group UserCommonFunction
    ./Kernel/User Common Function/Header/: UserCommonInclude.h UserCommonInterface.h UserCommonDdcciDefine.h
    ./Kernel/User Common Function/Code/: UserCommonAdjust.c UserCommonAuto.c UserCommonDdcciFunction.c UserCommonDisplayCalibrationGen0.c UserCommonDisplayCalibrationGen1.c UserCommonInterface.c UserCommonHDR.c UserCommonLocalDimming.c UserCommonModeSearch.c UserCommonNVRamSystem.c UserCommonTypecCommunication.c UserCommonPortControllerEmbedded.c UserCommonPortControllerRts5400.c UserCommonPortControllerUser.c UserCommonUsbHubUser.c UserCommonUsbHubRts5411.c UserCommonScalerDataExchange.c UserCommonSeamlessChg.c UserCommonPortControllerCommon.c UserCommonGlobalDimming.c UserCommonCec.c UserCommonDualBankUser.c UserCommonDualBankUserTable.c UserCommonDualBankUserTableII.c UserCommonFwUpdate.c UserCommonFwUpdateBackground.c UserCommonFwUpdateCrcTable.c UserCommonFwUpdateForeground.c UserCommonFwUpdatePassword.c UserCommonFwUpdateSignatureTable.c
  group RTD2014Function
    ./User/RTD Series/RTD2014Function/Header/: RTD2014UserInclude.h RTD2014UserModeTable.h
    ./User/RTD Series/RTD2014Function/Code/: RTD2014UserInterface.c RTD2014UserAdjust.c RTD2014UserAdjust3DGamma.c RTD2014UserAdjustOutputGamma.c RTD2014UserAdjustRGBGamma.c RTD2014UserAdjustUniformity.c RTD2014UserTypeCInterface.c RTD2014UserInterfaceHDR.c RTD2014UserInterfaceLocalDimming.c RTD2014UserInterfaceDimming.c RTD2014UserInterfaceGlobalDimming.c RTD2014UserInterfaceCec.c RTD2014UserTTSRecordList.c
  group RTD2014Osd
    ./User/RTD Series/RTD2014Osd/Header/: RTD2014Include.h RTD2014TimerInclude.h RTD2014TimerEventIDUser.h RTD2014Project.h RTD2014NVRamOsd.h
    ./User/RTD Series/RTD2014Osd/Code/: RTD2014NVRamOsd.c RTD2014Ddcci.c RTD2014Key.c RTD2014Osd.c RTD2014OsdDisplay.c RTD2014OsdFontProp.c RTD2014OsdFontTable.c RTD2014OsdFontVLC.c RTD2014OsdFunc.c RTD2014OsdPalette.c RTD2014OsdWindow.c RTD2014OsdFontDynamicIcon_1.c RTD2014OsdFontDynamicIcon_2.c RTD2014OsdPropPutStringFontTable.c RTD2014Ddcci_AutoAlign.c tFONT_CHINESE_F.C tFONT_CHINESE_S.C tFONT_Energy.c TFONT_ENGLISH.c tFONT_JAPANESE.c tFONT_KOREAN.c tFONT_ARABIC.C tFONT_HEBREW.C tFONT_VIETNAMESE.C
  group RTDFactory
    ./User/RTD Factory/Header/: RTDFactoryInclude.h
    ./User/RTD Factory/Code/: RTDFactoryFunction.c RTDFactoryMode.c
  group NoneFunction
    ./User/None Series/NoneFunction/Header/: NoneUserInclude.h NoneUserModeTable.h
    ./User/None Series/NoneFunction/Code/: NoneUserInterface.c NoneUserAdjust.c NoneUserAdjust3DGamma.c NoneUserAdjustOutputGamma.c NoneUserAdjustUniformity.c
  group NoneOsd
    ./User/None Series/NoneOsd/Header/: NoneInclude.h NoneTimerInclude.h NoneTimerEventIDUser.h NoneNVRamOsd.h
    ./User/None Series/NoneOsd/Code/: NoneOsdTable.c NoneDdcci.c NoneNVRamOsd.c NoneKey.c NoneOsd.c NoneOsdDisplay.c NoneOsdFont.c NoneOsdFunc.c
  group NoneFactory
    ./User/None Factory/Header/: NoneFactoryInclude.h
    ./User/None Factory/Code/: NoneFactoryFunction_RL6193.c NoneFactoryFunction_RL6369.c NoneFactoryFunction_RL6410.c NoneFactoryFunction_RL6432.c NoneFactoryFunction_RL6492.c
  group Device
    ./User/Device/Code/: Led_Driver_O2_OZ9913.c Led_Driver_AUSTRIA_AS3820.c Led_Driver_AUSTRIA_AS3824.c TypeC_Pmic_INTERSIL_RAA489800.c TypeC_Pmic_MPS_MP4247.c TypeC_Pmic_MPS_MP4248.c TypeC_Pmic_ONSEMI_NCP81239.c TypeC_Pmic_SILERGY_SY8665.c TypeC_Pmic_SILERGY_SY9228.c TypeC_Pmic_SILERGY_SY9329.c TypeC_Pmic_System_Solution.c TypeC_Pmic_VISHAY_SIC437A.c
target RL6410_Project (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: RL6410_Project +hex (library)
  BeforeMake: .\Tool\precompile\pch_support.bat @L !P "" "$K"
  AfterMake: ".\Tool\build\link.bat" "$K" !P @L
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RL6410_PROJECT, _SCALER_TYPE = _RL6410_SERIES
  c include: .\Output\RL6410;.\Project\Header;.\Pcb;.\Panel;.\Kernel\Device\Header;.\Kernel\Common;.\Kernel\System\Header;.\Kernel\Scaler\ScalerFunction\Header;.\Kernel\Scaler\ScalerCommonFunction\Header;.\Kernel\Scaler\ScalerFunction\Lib\Header;.\Kernel\Scaler\ScalerCommonFunction\Lib\Header;.\Kernel\Scaler\RL6410_Series_Scaler\Header;.\Kernel\Scaler\RL6410_Series_Scaler\Lib\Header;.\Kernel\Scaler\RL6410_Series_Common\Header;.\Kernel\Scaler\RL6410_Series_Common\Lib\Header;.\Kernel\User Common Function\Header;.\User\RTD Series\RTD2014Function\Header;.\User\RTD Series\RTD2014Osd\Header;.\User\RTD Factory\Header;.\User\None Series\NoneFunction\Header;.\User\None Series\NoneOsd\Header;.\User\None Factory\Header
  asm misc: DEFINE(_PROJECT=_RL6410_PROJECT,_SCALER_TYPE=_RL6410_SERIES)
  asm include: .\Project\Header;.\Kernel\Common
target RL6432_Project (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: RL6432_Project +hex (library)
  BeforeMake: .\Tool\precompile\pch_support.bat @L !P "" "$K"
  AfterMake: ".\Tool\build\link_hdr.bat" "$K" !P @L
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RL6432_PROJECT, _SCALER_TYPE = _RL6432_SERIES
  c include: .\Output\RL6432;.\Project\Header;.\Pcb;.\Panel;.\Kernel\Device\Header;.\Kernel\Common;.\Kernel\System\Header;.\Kernel\Scaler\ScalerFunction\Header;.\Kernel\Scaler\ScalerCommonFunction\Header;.\Kernel\Scaler\ScalerFunction\Lib\Header;.\Kernel\Scaler\ScalerCommonFunction\Lib\Header;.\Kernel\Scaler\RL6432_Series_Scaler\Header;.\Kernel\Scaler\RL6432_Series_Common\Header;.\Kernel\Scaler\RL6432_Series_Scaler\Lib\Header;.\Kernel\Scaler\RL6432_Series_Common\Lib\Header;.\Kernel\User Common Function\Header;.\User\RTD Series\RTD2014Function\Header;.\User\RTD Series\RTD2014Osd\Header;.\User\RTD Factory\Header;.\User\None Series\NoneFunction\Header;.\User\None Series\NoneOsd\Header;.\User\None Factory\Header
  asm misc: DEFINE(_PROJECT=_RL6432_PROJECT,_SCALER_TYPE=_RL6432_SERIES)
  asm include: .\Project\Header;.\Kernel\Common
target RL6449_Project (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: RL6449_Project +hex (library)
  BeforeMake: .\Tool\precompile\pch_support.bat @L !P "" "$K"
  AfterMake: ".\Tool\build\link_hdr.bat" "$K" !P @L
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RL6449_PROJECT, _SCALER_TYPE = _RL6449_SERIES
  c include: .\Output\RL6449;.\Project\Header;.\Pcb;.\Panel;.\Kernel\Device\Header;.\Kernel\Common;.\Kernel\System\Header;.\Kernel\Scaler\ScalerFunction\Header;.\Kernel\Scaler\ScalerCommonFunction\Header;.\Kernel\Scaler\ScalerFunction\Lib\Header;.\Kernel\Scaler\ScalerCommonFunction\Lib\Header;.\Kernel\Scaler\RL6449_Series_Scaler\Header;.\Kernel\Scaler\RL6449_Series_Scaler\Lib\Header;.\Kernel\Scaler\RL6449_Series_Common\Header;.\Kernel\Scaler\RL6449_Series_Common\Lib\Header;.\Kernel\User Common Function\Header;.\User\RTD Series\RTD2014Function\Header;.\User\RTD Series\RTD2014Osd\Header;.\User\RTD Factory\Header;.\User\None Series\NoneFunction\Header;.\User\None Series\NoneOsd\Header;.\User\None Factory\Header
  asm misc: DEFINE(_PROJECT=_RL6449_PROJECT,_SCALER_TYPE=_RL6449_SERIES)
  asm include: .\Project\Header;.\Kernel\Common
target RL6463_Project (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: RL6463_Project +hex (library)
  BeforeMake: .\Tool\precompile\pch_support.bat @L !P "" "$K"
  AfterMake: ".\Tool\build\link_hdr_gen0.bat" "$K" !P @L
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RL6463_PROJECT, _SCALER_TYPE = _RL6463_SERIES
  c include: .\Output\RL6463;.\Project\Header;.\Pcb;.\Panel;.\Kernel\Device\Header;.\Kernel\Common;.\Kernel\System\Header;.\Kernel\Scaler\ScalerFunction\Header;.\Kernel\Scaler\ScalerCommonFunction\Header;.\Kernel\Scaler\ScalerFunction\Lib\Header;.\Kernel\Scaler\ScalerCommonFunction\Lib\Header;.\Kernel\Scaler\RL6463_Series_Scaler\Header;.\Kernel\Scaler\RL6463_Series_Scaler\Lib\Header;.\Kernel\User Common Function\Header;.\User\RTD Series\RTD2014Function\Header;.\User\RTD Series\RTD2014Osd\Header;.\User\RTD Factory\Header;.\User\None Series\NoneFunction\Header;.\User\None Series\NoneOsd\Header;.\User\None Factory\Header
  asm misc: DEFINE(_PROJECT=_RL6463_PROJECT,_SCALER_TYPE=_RL6463_SERIES)
  asm include: .\Project\Header;.\Kernel\Common
target RL6492_Project (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: RL6492_Project +hex (library)
  BeforeMake: .\Tool\precompile\pch_support.bat @L !P "" "$K"
  AfterMake: ".\Tool\build\link.bat" "$K" !P @L
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RL6492_PROJECT, _SCALER_TYPE = _RL6492_SERIES
  c include: .\Output\RL6492;.\Project\Header;.\Pcb;.\Panel;.\Kernel\Device\Header;.\Kernel\Common;.\Kernel\System\Header;.\Kernel\Scaler\ScalerFunction\Header;.\Kernel\Scaler\ScalerCommonFunction\Header;.\Kernel\Scaler\ScalerFunction\Lib\Header;.\Kernel\Scaler\ScalerCommonFunction\Lib\Header;.\Kernel\Scaler\RL6492_Series_Scaler\Header;.\Kernel\Scaler\RL6492_Series_Scaler\Lib\Header;.\Kernel\Scaler\RL6492_Series_Common\Header;.\Kernel\Scaler\RL6492_Series_Common\Lib\Header;.\Kernel\User Common Function\Header;.\User\RTD Series\RTD2014Function\Header;.\User\RTD Series\RTD2014Osd\Header;.\User\RTD Factory\Header;.\User\None Series\NoneFunction\Header;.\User\None Series\NoneOsd\Header;.\User\None Factory\Header
  asm misc: DEFINE(_PROJECT=_RL6492_PROJECT,_SCALER_TYPE=_RL6492_SERIES)
  asm include: .\Project\Header;.\Kernel\Common
target RL6851_Project (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: RL6851_Project +hex (library)
  BeforeMake: .\Tool\precompile\pch_support.bat @L !P "" "$K"
  AfterMake: ".\Tool\build\link_hdr.bat" "$K" !P @L
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RL6851_PROJECT, _SCALER_TYPE = _RL6851_SERIES
  c include: .\Output\RL6851;.\Project\Header;.\Pcb;.\Panel;.\Kernel\Device\Header;.\Kernel\Common;.\Kernel\System\Header;.\Kernel\Scaler_Group2\RL6851_Series_Scaler\Header;.\Kernel\Scaler_Group2\RL6851_Series_Scaler\Lib\Header;.\Kernel\User Common Function\Header;.\User\RTD Series\RTD2014Function\Header;.\User\RTD Series\RTD2014Osd\Header;.\User\RTD Factory\Header;.\User\None Series\NoneFunction\Header;.\User\None Series\NoneOsd\Header;.\User\None Factory\Header
  asm misc: DEFINE(_PROJECT=_RL6851_PROJECT,_SCALER_TYPE=_RL6851_SERIES)
  asm include: .\Project\Header;.\Kernel\Common
